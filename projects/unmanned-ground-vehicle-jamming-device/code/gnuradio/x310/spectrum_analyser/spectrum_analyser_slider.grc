options:
  parameters:
    author: Jonas Augusto Kunzler
    generate_options: qt_gui
    id: spectrum_analyser_slider
    output_language: python
    title: Spectrum Analyser with Frequency Selector
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 3.5e9
  states: {}
- name: frequency_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency Selector
    start: frequency - 3e9
    step: 1E6
    stop: 3.8E9
    value: frequency
  states: {}
- name: samp_rate_sa
  id: variable
  parameters:
    value: 160e6
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_sa/2000
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_sa
    fc: frequency_slider
    fftsize: '8192'
    type: complex
    update_time: '0.05'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 160e6
    center_freq0: frequency
    dev_addr: addr=192.168.10.2
    gain0: '0'
    samp_rate: samp_rate_sa
    sd_spec0: A:0
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
